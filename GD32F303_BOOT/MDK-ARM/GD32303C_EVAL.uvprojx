# Keil uVision project GD32303C_EVAL.uvprojx, settings and files
target GD32F303C_EVAL (6220000::V6.22::ARMCLANG)
  device: GD32F303CE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=7 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,GD32F303RC,__FPU_PRESENT = 1
  c misc: -Wno-packed -Wno-missing-variable-declarations -Wno-missing-prototypes -Wno-missing-noreturn -Wno-sign-conversion
  c include: ..\;..\APP;..\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;..\..\01_GPIO_Running_LED;..\MDK-ARM;..\GD32F30x_Firmware_Library\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../APP/: gd32f30x_it.c main.c systick.c usart.c can.c
  group CMSIS
    ../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group GD32F30x_EVAL
    ../APP/: gd32f303c_eval.c
  group Startup
    ../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.0, Language Extension:PLOOC 4.6.4, Utilities:perf_counter:Core 2.3.3, MicroBoot:components:Bootloader 0.9.6, MicroBoot:components:FlashDrv 0.9.6, MicroBoot:components:check_agent_engine 0.9.6, MicroBoot:components:queue 0.9.6, MicroBoot:components:shell 0.9.7, MicroBoot:components:signals_slots 0.9.6, MicroBoot:components:ymodem 0.9.6, MicroBoot:example:ymodem_ota 0.9.6
