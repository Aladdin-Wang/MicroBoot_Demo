# Keil uVision project STM32F7_BOOT.uvprojx, settings and files
target STM32F7_BOOT (6220000::V6.22::ARMCLANG)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32F7_BOOT +hex
  AfterMake: fromelf --bin !L --output boot.bin
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F767xx,STM32F7x_1024
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Application/User/Core
    ../Core/Src/: STM32F7x_1024.FLM.c main.c gpio.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
software components: CMSIS:CORE 6.1.0, MicroBoot:components:Bootloader 0.9.6, MicroBoot:components:FlashDrv 0.9.6, MicroBoot:components:check_agent_engine 0.9.6, MicroBoot:components:no_semihosting 0.9.6, MicroBoot:components:queue 0.9.6, MicroBoot:components:shell 0.9.7, MicroBoot:components:signals_slots 0.9.6, MicroBoot:components:ymodem 0.9.6, MicroBoot:example:ymodem_ota 0.9.6
