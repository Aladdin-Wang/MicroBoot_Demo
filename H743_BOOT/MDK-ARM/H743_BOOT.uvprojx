# Keil uVision project H743_BOOT.uvprojx, settings and files
target H743_BOOT (6220000::V6.22::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: H743_BOOT +hex
  AfterMake: fromelf --bin !L --output boot.bin
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx FLASH_MEM STM32H7x_2048,STM32H743xx
  c misc: -Wno-invalid-source-encoding
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../App;../Serve;..\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 6.1.0, Compiler:I/O:STDOUT 1.2.0, MicroBoot:components:Bootloader 0.9.6, MicroBoot:components:FlashDrv 0.9.6, MicroBoot:components:check_agent_engine 0.9.6, MicroBoot:components:queue 0.9.6, MicroBoot:components:shell 0.9.7, MicroBoot:components:signals_slots 0.9.6, MicroBoot:components:subscribe_publish 0.9.6, MicroBoot:components:ymodem 0.9.6, MicroBoot:example:ymodem_ota 0.9.6
